# Keil uVision project ARM-M3 drivers.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ARM-M3 drivers +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./APP/: main.c main.h
  group RCC
    ./MCAL/RCC/: RCC_App.c RCC_Config.h RCC_interface.h RCC_Private.h
  group GPIO
    ./MCAL/GPIO/: GPIO_App.c GPIO_Interface.h GPIO_Private.h GPIO_Config.h
  group LIB
    ./LIB/: STD_TYPES.h BIT_MATH.h Helper_Functions.c Helper_Functions.h
  group NVIC
    ./MCAL/NVIC/: NVIC_App.c NVIC_Private.h NVIC_Interface.h NVIC_Config.h
  group EXTI
    ./MCAL/EXTI/: EXTI_App.c EXTI_Config.h EXTI_Interface.h EXTI_Private.h
  group AFIO
    ./MCAL/AFIO/: AFIO_App.c AFIO_Config.h AFIO_Interface.h AFIO_Private.h
  group SYSTICK
    ./MCAL/SYSTICK/: SYSTICK_App.c SYSTICK_Config.h SYSTICK_Interface.h SYSTICK_Private.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
